# Keil uVision project spi-old.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi-old +hex
  AfterMake: D:\mdk\ARM\ARMCC\bin\fromelf.exe --bin -o  output\spi-oled.bin  output\spi-old.axf
  c flags: Optim=1 wLevel=2
  c include: .\app;.\spi;.\user
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x2001a000 size 0x6000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./app/: delay.c sys.c
    ./spi/: spi.c
    ./user/: main.c oled.c
  group ::Device
    RTE/Device/STM32F407ZG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1
