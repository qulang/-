# Keil uVision project sd.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sd
  c flags: Optim=1 wLevel=2
  c include: ..\app;..\user;..\FATFS\src;..\FATFS\exfuns;..\USMART;..\gc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: delay.c lcd.c sd.c usart.c sys.c flash.c malloc.c key.c
  group user
    ../user/: main.c
  group fatfs
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: fattester.c exfuns.c
  group ::Device
    RTE/Device/STM32F407ZG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.3.1
